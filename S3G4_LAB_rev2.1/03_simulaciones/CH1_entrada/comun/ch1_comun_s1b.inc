* S1b P4b. CPL DC=0 AC=1 GND=2. All derived design values remain .param.
.param RT1=549k RB=11k RS1=49.9k RS2=49.9k RBIAS=10Meg REQ=10Meg
.param RPROT=1k CAC=1.8n CBNC=3p CX1=2p CTAP=2p
.param COFF_RELE=1p RON_RELE=0.1 CSEL_PAR=3p COFF_SW=0.5p CIN_BUF=5p CJO=1.5p
.param VJ_D=0.6 M_D=0.3 CJ_POL=CJO/(1+5/VJ_D)**M_D
.param RS=RS1+RS2 RBP=RB*RBIAS/(RB+RBIAS)
.param C_SEL_EST=2*CJ_POL+CSEL_PAR+CIN_BUF+2*COFF_SW
.param CEQ=C_SEL_EST CX1_TOT=CX1+COFF_RELE+C_SEL_EST CS=RBIAS*CX1_TOT/RS
.subckt RAILS VP VN
VPI VPI 0 5
RVP VPI VP 1
VNI VNI 0 -5
RVN VNI VN 1
.ends RAILS
.subckt FRONT_P4B BNC OUT VP VN params: POS=100 CPL=0 CT1=20p RANGO=1
+ CTRIM=4p DTRIM=0 CEQSEL={CEQ}
+ FRT1=1 FRT2=1 FRB=1 FRS1=1 FRS2=1 FRBIAS=1 FREQ=1
+ FCT1=1 FCT2F=1 FCB=1 FCS=1 FCEQ=1 FCAC=1
+ FCOFF=1 FCSEL=1 FCIN=1 FCJO=1 FCX1=1 FCBNC=1 FCSW=1
.param CTRIM_MIN=if(RANGO==1,2p,if(RANGO==2,3p,5p))
.param CTRIM_MAX=if(RANGO==1,6p,if(RANGO==2,10p,20p))
.param CTRIM_MED=(CTRIM_MIN+CTRIM_MAX)/2 CT2F=CT1-CTRIM_MED
.param CB=(CT1/2+COFF_RELE)*2*RT1/RBP-(C_SEL_EST+CTAP)
.model DBAV199 D(IS=1e-12 N=1.9 RS=1.5 CJO={CJO*FCJO} M={M_D} VJ={VJ_D} BV=85 IBV=1n)
Rt1 BNC M {RT1*FRT1}
Rt2 M TAP {RT1*FRT2}
Ct1 BNC M {CT1*FCT1}
Ct2fixed M TAP {CT2F*FCT2F}
Ct2trim M TAP {CTRIM+DTRIM}
Rb TAP 0 {RB*FRB}
Cb TAP 0 {CB*FCB}
Ctap TAP 0 {CTAP}
Rs1 BNC RSM {RS1*FRS1}
Rs2 RSM X1 {RS2*FRS2}
Cs BNC X1 {CS*FCS}
Cx1 X1 0 {CX1*FCX1}
Cbnc BNC 0 {CBNC*FCBNC}
Rk1a100 TAP SEL {if(POS==100,RON_RELE,1e18)}
Rk1a1 X1 SEL {if(POS==1,RON_RELE,1e18)}
Ck1a1 X1 SEL {if(POS==100,COFF_RELE*FCOFF,0)}
Ck1a100 TAP SEL {if(POS==1,COFF_RELE*FCOFF,0)}
Rk1b X1 EQ {if(POS==100,RON_RELE,1e18)}
Ck1b X1 EQ {if(POS==1,COFF_RELE*FCOFF,0)}
Req EQ 0 {REQ*FREQ}
Ceq EQ 0 {CEQSEL*FCEQ}
DHP SEL VP DBAV199
DLP VN SEL DBAV199
Csel SEL 0 {CSEL_PAR*FCSEL}
CAc SEL T2 {CAC*FCAC}
RswDC B SEL {if(CPL==0,RON_RELE,1e18)}
RswAC B T2 {if(CPL==1,RON_RELE,1e18)}
RswGND B 0 {if(CPL==2,RON_RELE,1e18)}
CswDC B SEL {if(CPL==0,0,COFF_SW*FCSW)}
CswAC B T2 {if(CPL==1,0,COFF_SW*FCSW)}
CswGND B 0 {if(CPL==2,0,COFF_SW*FCSW)}
Rbias B 0 {RBIAS*FRBIAS}
Rprot B BI {RPROT}
Cin BI 0 {CIN_BUF*FCIN}
Ebuf OUT 0 BI 0 1
.ends FRONT_P4B
