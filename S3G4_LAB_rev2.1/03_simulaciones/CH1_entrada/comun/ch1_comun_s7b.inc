* S7b: immutable S7 included for constants and reusable model wrappers only.
* Active channel/rails/front-end are the new subcircuits below.
.include "ch1_comun_s7.inc"
.param AFE_S7B=4.90 CS_S7B=1.20n CEQ_S7B=8.67p
.subckt RAILS_S7B VP VN params: POWER=1 BLEED=0 RP=4.90 RN=4.90
VPI PP 0 {RP}
RVP PP PDEL 0.5
DVP PDEL PREG DELIVERY
VNI NN 0 {-RN}
RVN NDEL NN 0.5
DVN NREG NDEL DELIVERY
RLOADSWP PREG VP {if(POWER==1,1u,1e18)}
RLOADSWN VN NREG {if(POWER==1,1u,1e18)}
CbulkP VP 0 {if(POWER==1,10u,1u)}
CbulkN VN 0 {if(POWER==1,10u,1u)}
CdecP VP 0 100n
CdecN VN 0 100n
* Existing load resistors are unchanged (not a new load-current decision).
RloadP VP 0 {if(POWER==1,5/42m,1Meg)}
RloadN VN 0 {if(POWER==1,5/39m,1Meg)}
RbleedP VP 0 {if(POWER==1,1e18,if(BLEED==0,1e18,if(BLEED==1,10k,100)))}
RbleedN VN 0 {if(POWER==1,1e18,if(BLEED==0,1e18,if(BLEED==1,10k,100)))}
DtvsP 0 VP DTVS
DtvsN VN 0 DTVS
.ends RAILS_S7B
.subckt FRONT_S7B BNC BI VP VN M TAP RSM X1 EQ SEL B T2 params: POS=100 CPL=0
Rt1 BNC M {RT1}
Rt2 M TAP {RT1}
Ct1 BNC M {CT1}
Ct2fixed M TAP {CT2F}
Ct2trim M TAP {CTRIM}
Rb TAP 0 {RB}
Cb TAP 0 {CB}
Ctap TAP 0 {CTAP}
Rs1 BNC RSM {RS1}
Rs2 RSM X1 {RS2}
Cs BNC X1 {CS_S7B}
Cx1 X1 0 {CX1}
Cbnc BNC 0 {CBNC}
Rk1a100 TAP SEL {if(POS==100,RON_RELE,1e18)}
Rk1a1 X1 SEL {if(POS==1,RON_RELE,1e18)}
Ck1a1 X1 SEL {if(POS==100,COFF_RELE,0)}
Ck1a100 TAP SEL {if(POS==1,COFF_RELE,0)}
Rk1b X1 EQ {if(POS==100,RON_RELE,1e18)}
Ck1b X1 EQ {if(POS==1,COFF_RELE,0)}
Req EQ 0 {REQ}
Ceq EQ 0 {CEQ_S7B}
DHP SEL VP BAV199
DLP VN SEL BAV199
Csel SEL 0 {CSEL_PAR}
CAc SEL T2 {CAC}
RswDC B SEL {if(CPL==0,RON_RELE,1e18)}
RswAC B T2 {if(CPL==1,RON_RELE,1e18)}
RswGND B 0 {if(CPL==2,RON_RELE,1e18)}
CswDC B SEL {if(CPL==0,0,COFF_SW)}
CswAC B T2 {if(CPL==1,0,COFF_SW)}
CswGND B 0 {if(CPL==2,0,COFF_SW)}
Rbias B 0 {RBIAS}
Rprot B BI {RPROT}
Cin BI 0 {CIN_BUF}
.ends FRONT_S7B
.subckt MUX_S7B Y0 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Z A0 A1 A2 VP VN
Bcode CODE 0 V=if(V(A0)>2.5,1,0)+2*if(V(A1)>2.5,1,0)+4*if(V(A2)>2.5,1,0)
B0 D0 0 V=if(V(CODE)==0,0,V(VP))
B1 D1 0 V=if(V(CODE)==1,0,V(VP))
B2 D2 0 V=if(V(CODE)==2,0,V(VP))
B3 D3 0 V=if(V(CODE)==3,0,V(VP))
B4 D4 0 V=if(V(CODE)==4,0,V(VP))
B5 D5 0 V=if(V(CODE)==5,0,V(VP))
B6 D6 0 V=if(V(CODE)==6,0,V(VP))
B7 D7 0 V=if(V(CODE)==7,0,V(VP))
R0 D0 C0 1
R1 D1 C1 1
R2 D2 C2 1
R3 D3 C3 1
R4 D4 C4 1
R5 D5 C5 1
R6 D6 C6 1
R7 D7 C7 1
C0 C0 0 1f
C1 C1 0 1f
C2 C2 0 1f
C3 C3 0 1f
C4 C4 0 1f
C5 C5 0 1f
C6 C6 0 1f
C7 C7 0 1f
X0 C0 Y0 Z VN VP 0 SWI1
X1 C1 Y1 Z VN VP 0 SWI1
X2 C2 Y2 Z VN VP 0 SWI1
X3 C3 Y3 Z VN VP 0 SWI1
X4 C4 Y4 Z VN VP 0 SWI1
X5 C5 Y5 Z VN VP 0 SWI1
X6 C6 Y6 Z VN VP 0 SWI1
X7 C7 Y7 Z VN VP 0 SWI1
.ends MUX_S7B
.subckt SK_S7B IN OUT VP VN IP IM params: RA=1k RB=1k CF=100p CG=100p VOS=0
R1 IN MID {RA}
R2 MID PLUS {RB}
C1 MID OUT {CF}
C2 PLUS 0 {CG}
CPCB PLUS 0 {CPCB_S7}
VIP PLUS IP 0
VOS IP IPR {VOS}
VIM OUT IM 0
VCCP VP VPP 0
VCCN VN VNN 0
XAMP IPR IM VPP VNN OUT AD8038
.ends SK_S7B
.subckt CHANNEL_S7B BNC PIN VP VN VDDA VREF DAC params: POS=1 CODE=0 CPL=0 VO101=0 VOA=0 VOB=0 VOFA=0 VOFB=0 VO836=0
XFE BNC RAWIN VP VN M TAP RSM X1 EQ SEL B T2 FRONT_S7B POS={POS} CPL={CPL}
VI101 RAWIN BI 0
VOS101 BI BIR {VO101}
VIM101 BO U101M 0
VIP101 VP VP101 0
VIN101 VN VN101 0
X101 BIR U101M BO_DRIVE VP101 VN101 OPA810
VOUT101 BO_DRIVE BO 0
XLAD BO Y1 Y2 Y3 Y4 Y5 LADDER_S3
RVCHECK Y7 0 {R_VCHECK_S7}
XMUX BO Y1 Y2 Y3 Y4 Y5 0 Y7 COMMON A0 A1 A2 MVP MVN MUX_S7B
VMUXP VP MVP 0
VMUXN VN MVN 0
BA0 A0 0 V=V(VP)*mod(CODE,2)
BA1 A1 0 V=V(VP)*mod(floor(CODE/2),2)
BA2 A2 0 V=V(VP)*floor(CODE/4)
CPCB COMMON 0 {C_COMMON_S7}
VIA COMMON SERA 0
VIB OA SERB 0
XPROTA SERA IPA IMA PROTECT_BAV99 R_SER={R_SER_S7}
XPROTB SERB IPB IMB PROTECT_BAV99 R_SER={R_SER_S7}
VOSA IPA IPAR {VOA}
VOSB IPB IPBR {VOB}
VIMA MA IMA 0
VIMB MB IMB 0
VIPA VP VPA 0
VINA VN VNA 0
VIPB VP VPB 0
VINB VN VNB 0
X103A IPAR IMA VPA VNA OA AD8038
X103B IPBR IMB VPB VNB OUT AD8038
RFA OA MA {RF1}
RGA MA 0 {RG1}
CMA MA 0 {C_GAIN_S7}
RFB OUT MB {RF2}
RGB MB 0 {RG2}
CMB MB 0 {C_GAIN_S7}
X105A OUT OA105 VP VN IPA105 IMA105 SK_S7B RA={RFILT1_S7} RB={RFILT1_S7} CF={CFILT1_S7} CG={CGILT1_S7} VOS={VOFA}
X105B OA105 FILTEROUT VP VN IPB105 IMB105 SK_S7B RA={RFILT2_S7} RB={RFILT2_S7} CF={CFILT2_S7} CG={CGILT2_S7} VOS={VOFB}
RT VREF VM {RT_MID}
RB VM 0 {RB_MID}
CMID VM 0 {C_MID_S7}
RIN FILTEROUT SUM {R_IN_S4}
ROFF DAC SUM {R_OFF_S4}
RF O SUM {R_F_S4}
CF O SUM {C_FB_S7}
CSUM SUM 0 {C_SUM_S4}
VIP VM IP 0
VOS836 IP IPR {VO836}
VIM SUM IM 0
VCC VDDA VCC 0
XAMP IPR IM O VCC 0 VDDA OPA836_S4_ESD
RADC O PIN {R_ADC_S4}
CADC PIN 0 {C_ADC_S4}
CPAD PIN 0 {CPAD_S6}
.ends CHANNEL_S7B
